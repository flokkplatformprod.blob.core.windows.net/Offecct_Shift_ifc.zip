Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-01-22T12:10:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 22 12:10:02 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{1BF6C5B7-4823-41E1-9881-7FCB0595B8F6}\ifc * Database version: 5507 * Database creation date: Wed Jan 22 12:10:02 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 22 12:10:02 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 22 12:10:02 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Shift_Classic_Wood_Offecct, Shift_Classic_Wood_Offecct:Shift_Classic_Wood_Offecct:322344
In: Level 1
Type - Material: Natural Oak F1079, Kvadrat Halligndal 754
Type - General(Type) - BIMObjectName: Shift_Classic_Wood_Offecct; ConvergoRefNr: 0019-1802-0001-SE; ManufacturerName: Offecct; ManufacturerURL: https://www.offecct.com/; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_12_26; Uniclass2015Description: Easy chairs; Uniclass2015Reference: Pr_40_50_12_26; Version: 1; VersionDate: 10/01/2020
Type - Identity Data(Type) - Collection: Shift; Cost: 0; Designer: Daniel Debasi and Fredrico Sandri; Manufacturer: Offecct; Model: Shift Classic Wood Easy Chair; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; Type Name: Shift_Classic_Wood_Offecct; URL: https://www.offecct.com/family/shift/
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Offecct; Category: Easy Chair; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Shift_Classic_Wood_Offecct; Features: n/a; Finish: Wooden frame with cold foam, durable bottom in black polypropylene.; Grade: n/a; Material: Fabric & wood; ModelNumber: n/a; ModelReference: n/a; Name: Shift Classic Wood; ReplacementCost: n/a; Shape: Sculptured; Size: 860x825x760 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Offecct
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.9901 m2; Volume: 0.53922 m3
Materials and Finishes - SofaMainMaterial: Kvadrat Halligndal 754; SofaSecondaryMaterial: Natural Oak F1079
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Shift_Classic_Wood_Offecct: Shift_Classic_Wood_Offecct; Family and Type: Shift_Classic_Wood_Offecct: Shift_Classic_Wood_Offecct; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Shift_Classic_Wood_Offecct: Shift_Classic_Wood_Offecct; Type Id: Shift_Classic_Wood_Offecct: Shift_Classic_Wood_Offecct; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
