Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-31T10:16:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 31 10:16:07 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{CE6CDF75-D727-44DF-9A19-D689195F2FD0}\ifc * Database version: 5507 * Database creation date: Fri Aug 31 10:16:07 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 31 10:16:07 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 31 10:16:07 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Shift_Classic_Easy_Chair_Offecct, Shift_Classic_Easy_Chair_Offecct:Shift_Classic_Easy_Chair_Offecct:318276
In: Level 1
Material: Grey Metal RAL 7046, Swing Red 52411
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Offecct
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.9901 m2; Volume: 0.53922 m3
Materials and Finishes - SofaMainMaterial: Swing Red 52411; SofaSecondaryMaterial: Grey Metal RAL 7046
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Shift_Classic_Easy_Chair_Offecct: Shift_Classic_Easy_Chair_Offecct; Family and Type: Shift_Classic_Easy_Chair_Offecct: Shift_Classic_Easy_Chair_Offecct; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Shift_Classic_Easy_Chair_Offecct: Shift_Classic_Easy_Chair_Offecct; Type Id: Shift_Classic_Easy_Chair_Offecct: Shift_Classic_Easy_Chair_Offecct; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - BIMObjectName: Shift_Classic_Easy_Chair_Offecct; ConvergoRefNr: 0019-1802-0001-SE; ManufacturerName: Offecct; ManufacturerURL: https://www.offecct.com/; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_12_26; Uniclass2015Description: Easy chairs; Uniclass2015Reference: Pr_40_50_12_26; Version: 1; VersionDate: 27/08/2018
Identity Data(Type) - Collection: Shift; Cost: 0; Designer: Daniel Debasi and Fredrico Sandri; EANNumber: n/a; Manufacturer: Offecct; Model: Shift Classic Easy Chair; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; Type Name: Shift_Classic_Easy_Chair_Offecct
Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Offecct; Category: Easy Chair; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Shift_Classic_Easy_Chair_Offecct; Features: n/a; Finish: Legs in grey laquer, optional in silver, white or black; Grade: n/a; Material: Fabric & metal; ModelNumber: 8151102; ModelReference: n/a; Name: Shift Classic; ReplacementCost: n/a; Shape: Sculptured; Size: 860x825x760 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
