Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-05-22T16:07:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 22 16:07:37 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{3A2CDCAC-0C6A-47BE-9882-B9951CFAC1AC}\ifc * Database version: 5507 * Database creation date: Tue May 22 16:07:36 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 22 16:07:36 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 22 16:07:36 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFurnishingElement: Shift_Ottoman_Offecct, Shift_Ottoman_Offecct:Shift_Ottoman_Offecct:313604
In: Level 1
Type - Material: Grey Metal RAL 7046, Kvadrat Hallingdal 674
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Offecct
